# Keil uVision project pet_feeder.uvprojx, settings and files
target pet_feeder (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pet_Feeder +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\usart;..\User\adc;..\User\lcd;..\User\Led;..\User\key_exti;..\User\Delay;..\User\run;..\mcu_sdk;..\User\stepper_motor;..\rtthread\components\finsh;..\rtthread\include\libc;..\rtthread\include;..\User\light;..\User\hx711
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c board.c rtconfig.h
    ../User/usart/: bsp_usart.c
    ../User/font/: fonts.c
    ../User/adc/: bsp_adc.c
    ../User/Led/: bsp_led.c
    ../User/key_exti/: bsp_key_exti.c
    ../User/Delay/: delay.c
    ../User/run/: run.c
    ../User/stepper_motor/: bsp_stepper_motor.c
    ../User/light/: bsp_light.c
    ../User/hx711/: bsp_hx711_export.c bsp_hx711_granary.c
  group DOC
    ../Doc/: readme.txt
  group SDK
    ../mcu_sdk/: mcu_api.c protocol.c system.c
  group rtt/Kernel
    ../rtthread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group rtt/Ports
    ../rtthread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group rtt/Finsh
    ../rtthread/components/finsh/: cmd.c msh.c shell.c
